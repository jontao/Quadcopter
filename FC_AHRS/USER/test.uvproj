# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1
  c define: __TARGET_FPU_VFP_SINGLE,__TARGET_FPU_SOFTVFP
  c include: ..\SYSTEM\system;..\SYSTEM\delay;..\HARDWARE\inc;..\HARDWARE;..\HARDWARE\I2C;..\HARDWARE\MPU6050;..\HARDWARE\HMC5883;..\COMMON;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\POWER;..\USER;..\HARDWARE\MS5611;..\HARDWARE\LCDDRIVER;..\arithmetic;..\HARDWARE\UART;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;.\eMPL;..\PID
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s test.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/UART/: UARTs.c
    ../HARDWARE/I2C/: I2C.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/HMC5883/: HMC5883L.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/MS5611/: MS5611.c
    ../HARDWARE/NRF24L01/: nrf24l01.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/system/: sys.c
    ../SYSTEM/delay/: delay.c
  group New Group
    ../PID/: PID.c
